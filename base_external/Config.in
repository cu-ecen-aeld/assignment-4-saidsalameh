## base_external/Config.in
```kconfig
menu "External packages"

source "/home/vboxuser/assignment-4-saidsalameh/base_external/package/aesd-assignments/Config.in"


endmenu
```
